Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-30T13:27:37+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Interface utilisateur alternative 23.0.11.19

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Surface:269184
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m

# IfcSite: Village buildings:Village buildings, Village buildings:Village buildings:273019
Material: Buildings (8)

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Ligne du Niveau, Niveau 0
LongName: Niveau 0; Elevation: 260 m
